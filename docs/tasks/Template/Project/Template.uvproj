# Keil uVision project Template.uvproj, settings and files
target Template (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\User\timer;..\User\uart;..\Hardware\digital_tube;..\Hardware\ds1302;..\Hardware\key_board;..\Hardware\lcd1602;..\Library\delay
  group User
    ../User/: main.c config.h
    ../User/uart/: uart.c
    ../User/timer/: timer.c
  group Library
    ../Library/delay/: delay.c
  group Hardware
    ../Hardware/digital_tube/: digital_tube.c
    ../Hardware/ds1302/: ds1302.c
    ../Hardware/key_board/: key_board.c
    ../Hardware/lcd1602/: lcd1602.c
  group Documents
    ../Documents/: readme.txt
